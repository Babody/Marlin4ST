# IAR project Marlin4ST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F411xE; MARLIN; NO_WIFI; STM_3DPRINT
  ICCARM.CCIncludePath2: C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\STM32F4xx_HAL_Driver\Inc; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Projects\Inc; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\CMSIS\Device\ST\STM32F4xx\Include; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\CMSIS\Include; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\BSP\STM32F4xx-3dPrinter; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\BSP\MotorControl; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\BSP\Components\Common; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\FatFs\src; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\Marlin; C:\Users\jav\Documents\GitHub\Marlin4ST\stm32_cube\STM32\Drivers\BSP\Components\l6474
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group stm32_cube/Marlin
    ../stm32_cube/Marlin/: blinkm.cpp blinkm.h boards.h buzzer.h cardreader.cpp cardreader.h circularqueue.h Conditionals.h Conditionals_LCD.h Conditionals_post.h Configuration.h Configuration_adv.h configuration_store.cpp configuration_store.h dac_mcp4728.cpp dac_mcp4728.h digipot_mcp4451.cpp dogm_bitmaps.h dogm_font_data_6x9_marlin.h dogm_font_data_HD44780_C.h dogm_font_data_HD44780_J.h dogm_font_data_HD44780_W.h dogm_font_data_ISO10646_1.h dogm_font_data_ISO10646_5_Cyrillic.h dogm_font_data_ISO10646_CN.h dogm_font_data_ISO10646_Greek.h dogm_font_data_ISO10646_Kana.h dogm_font_data_Marlin_symbols.h duration_t.h endstops.cpp endstops.h enum.h language.h language_an.h language_bg.h language_ca.h language_cn.h language_cz.h language_da.h language_de.h language_el-gr.h language_el.h language_en.h language_es.h language_eu.h language_fi.h language_fr.h language_gl.h language_hr.h language_it.h language_kana.h language_kana_utf8.h language_nl.h language_pl.h language_pt-br.h language_pt-br_utf8.h language_pt.h language_pt_utf8.h language_ru.h language_test.h M100_Free_Mem_Chk.cpp macros.h Marlin.h Marlin_export.h Marlin_main.cpp MarlinConfig.h MarlinSerial.cpp MarlinSerial.h mesh_bed_leveling.cpp mesh_bed_leveling.h nozzle.h pins.h pins_STM_3DPRINT.h planner.cpp planner.h planner_bezier.cpp planner_bezier.h point_t.h printcounter.cpp printcounter.h qr_solve.cpp qr_solve.h SanityCheck.h Sd2Card.cpp Sd2Card.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h servo.cpp servo.h stepper.cpp stepper.h stepper_dac.cpp stepper_dac.h stepper_indirection.cpp stepper_indirection.h stopwatch.cpp stopwatch.h temperature.cpp temperature.h thermistornames.h thermistortables.h twibus.cpp twibus.h types.h ultralcd.cpp ultralcd.h ultralcd_impl_DOGM.h ultralcd_impl_HD44780.h ultralcd_st7920_u8glib_rrd.h utf_mapper.h utility.cpp utility.h vector_3.cpp vector_3.h Version.h watchdog.cpp watchdog.h
  group stm32_cube/STM32/Drivers/BSP/Components/Common
    ../stm32_cube/STM32/Drivers/BSP/Components/Common/: accelero.h audio.h camera.h epd.h gyro.h io.h lcd.h motor.h ts.h tsensor.h
  group stm32_cube/STM32/Drivers/BSP/Components/l6474
    ../stm32_cube/STM32/Drivers/BSP/Components/l6474/: l6474.c l6474.h l6474_target_config.h
  group stm32_cube/STM32/Drivers/BSP/MotorControl
    ../stm32_cube/STM32/Drivers/BSP/MotorControl/: motorcontrol.c motorcontrol.h
  group stm32_cube/STM32/Drivers/BSP/STM32F4xx-3dPrinter
    ../stm32_cube/STM32/Drivers/BSP/STM32F4xx-3dPrinter/: stm32f4xx_3dprinter_adc.c stm32f4xx_3dprinter_adc.h stm32f4xx_3dprinter_misc.c stm32f4xx_3dprinter_misc.h stm32f4xx_3dprinter_motor.c stm32f4xx_3dprinter_motor.h stm32f4xx_3dprinter_rpi.c stm32f4xx_3dprinter_rpi.h stm32f4xx_3dprinter_sd.c stm32f4xx_3dprinter_sd.h stm32f4xx_3dprinter_uart.c stm32f4xx_3dprinter_uart.h stm32f4xx_3dprinter_wifi.c stm32f4xx_3dprinter_wifi.h
  group stm32_cube/STM32/Drivers/CMSIS/Include
    ../stm32_cube/STM32/Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Inc
    ../stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy
    ../stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Src
    ../stm32_cube/STM32/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group stm32_cube/STM32/FatFs/src
    ../stm32_cube/STM32/FatFs/src/: diskio.c diskio.h ff.c ff.h ffconf_base.h integer.h sd_mmc_diskio.h
  group stm32_cube/STM32/FatFs/src/option
    ../stm32_cube/STM32/FatFs/src/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syscall.c unicode.c
  group stm32_cube/STM32/Projects/Inc
    ../stm32_cube/STM32/Projects/Inc/: ffconf.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group stm32_cube/STM32/Projects/Src
    ../stm32_cube/STM32/Projects/Src/: clock_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
